# Keil uVision project uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\SC_FPT\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c _uart.c PIT_TM.c LED.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
