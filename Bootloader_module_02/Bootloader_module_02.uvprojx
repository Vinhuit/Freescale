# Keil uVision project Bootloader_module_02.uvprojx, settings and files
target Bootloader (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Bootloader_module_02
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Scr
    ./: main.c BL_DrvLed.c BL_DrvSw.c BL_DrvUart.c SysTick.h BL_DrvTimer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
