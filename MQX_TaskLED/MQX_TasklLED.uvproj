# Keil uVision project MQX_TasklLED.uvproj, settings and files
target MQX_TaskTimer (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: MQX_TaskTimer_frdmkl46
  c flags: Optim=1 wLevel=2
  c include: ".\MQXLITE\include";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\MQXLITE\psp\cortex_m\core\M0";".\MQXLITE\psp\cortex_m\compiler\rv";".\Static_Code\PDD";".\Static_Code\IO_Map";".\Sources";".\Generated_Code";".\Generated_Code";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\Project_Settings\Startup_Code";".\Sources";".\MQXLITE\psp\cortex_m\core\M0"
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  link misc: --entry=__boot
  group GeneratedASMs
    ./MQXLITE/psp/cortex_m/core/M0/: boot.S dispatch.S
  group GeneratedCs
    ./Generated_Code/: Cpu.c CsIO1.c GPIO1.c IO1.c MQX1.c PE_LDD.c SystemTimer1.c Vectors.c LED.c
    ./Sources/: Events.c main.c mqx_tasks.c Seg_LCD.c
    ./MQXLITE/psp/cortex_m/: cortex.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c mem_zero.c psp_iinit.c psp_supp.c psp_tiad.c psp_tinm.c psp_tipr.c psp_tisu.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
    ./MQXLITE/kernel/: idletask.c int.c klog.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mqx_utils.c mqxlite.c mutex.c qu_test.c sched.c task.c time_ticks.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
    ./MQXLITE/config/: task_template_list.c
  group GeneratedHs
    ./Static_Code/PDD/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMAMUX_PDD.h DMA_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LCD_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SAI_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART0_PDD.h UART_PDD.h USB_PDD.h
    ./Generated_Code/: Cpu.h CsIO1.h GPIO1.h IO1.h IO_Map.h MQX1.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h SystemTimer1.h LED.h
    ./Sources/: Events.h mqx_tasks.h Seg_LCD.h
    ./Static_Code/IO_Map/: MKL46Z4.h
    ./MQXLITE/psp/cortex_m/compiler/rv/: asm_mac.h comp.h
    ./MQXLITE/psp/cortex_m/: cortex.h kinetis.h psp_comp.h psp_cpu.h psp_cpudef.h psp_prv.h psp_supp.h psp_ticks.h psplite.h psptypes.h
    ./MQXLITE/include/: klog.h log.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwsem_prv.h lwtimer.h lwtimer_prv.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_macros.h mqx_str.h mqxlite.h mqxlite_cnfg.h mqxlite_prv.h mutex.h mutex_prv.h queue.h
    ./MQXLITE/config/: task_template_list.h user_config.h
