# Keil uVision project Blink_FREQ.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blink_FREQ +hex
  AfterMake: fromelf --m32 --output=Blinky.srec Objects\Blink_FREQ.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\SC_FPT\LCD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Blink_FREQ
    ./: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
