# Keil uVision project Final_test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Final_test
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: Final_test.sct
  group Source Group 1
    ./: _uart.c Button.c LED.c main.c PIT_TM.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
