# Keil uVision project Clock_FEI_PEE.uvprojx, settings and files
target Clock_FEI_PEE (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Clock_FEI_PEE
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source
    ./: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
