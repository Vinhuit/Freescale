# Keil uVision project timer.uvprojx, settings and files
target timer (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: timer
  AfterMake: fromelf --m32 --output=Blinky.srec Objects\timer.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\SC_FPT\LCD
  memory RVCT4: ROM 0x1fffe000 size 0x6000
  memory RVCT9: RAM 0x20004000 size 0x2000
  group Source
    ./: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
