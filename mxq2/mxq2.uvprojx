# Keil uVision project mxq2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mxq2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ".\MQXLITE\include";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\MQXLITE\psp\cortex_m\core\M0";".\MQXLITE\psp\cortex_m\compiler\rv";".\PDD";".\Static_Code\IO_Map";".\Sources";".\Generated_Code";".\Generated_Code";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\Project_Settings\Startup_Code";".\Sources";".\MQXLITE\psp\cortex_m\core\M0"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./Sources/: main.c
