# Keil uVision project Bootloader_module_01.uvprojx, settings and files
target Bootloader (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Bootloader_module_01
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Src
    ./: main.c DrvLED.c DrvSW.c Seg_LCD.c DrvUART.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
