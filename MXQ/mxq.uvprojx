# Keil uVision project mxq.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mxq
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ".\MQXLITE\include";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\MQXLITE\psp\cortex_m\core\M0";".\MQXLITE\psp\cortex_m\compiler\rv";".\Static_Code\PDD";".\Static_Code\IO_Map";".\Sources";".\Generated_Code";".\Generated_Code";".\MQXLITE\config";".\MQXLITE\kernel";".\MQXLITE\psp\cortex_m";".\Project_Settings\Startup_Code";".\Sources";".\MQXLITE\psp\cortex_m\core\M0"
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c
  group New Group1
    ./Generated_Code/: Cpu.c CsIO1.c IO1.c MQX1.c PE_LDD.c SystemTimer1.c Vectors.c
    ./MQXLITE/kernel/: idletask.c int.c klog.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwsem.c lwtimer.c mqx_utils.c mqxlite.c mutex.c qu_test.c sched.c task.c time_ticks.c
    ./MQXLITE/config/: task_template_list.c task_template_list.h user_config.h
    ./MQXLITE/include/: klog.h log.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwsem_prv.h lwtimer.h lwtimer_prv.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_macros.h mqx_str.h mqxlite.h mqxlite_cnfg.h mqxlite_prv.h mutex.h mutex_prv.h queue.h
    ./MQXLITE/psp/cortex_m/: cortex.c cortex.h int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c kinetis.h mem_zero.c psp_comp.h psp_cpu.h psp_cpudef.h psp_iinit.c psp_prv.h psp_supp.c psp_supp.h psp_tiad.c psp_ticks.h psp_tinm.c psp_tipr.c psp_tisu.c psplite.h psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c types.inc
  group New Group
    ./Static_Code/PDD/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMA_PDD.h DMAMUX_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LCD_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SAI_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART_PDD.h UART0_PDD.h USB_PDD.h
